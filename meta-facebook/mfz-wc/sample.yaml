## meta-facebook/mfz-wc/sample.yaml
```yaml
tests:
  portability.cmsis_rtos_v2:
    tags: cmsis_rtos
sample:
  description: mfz_tmp
  name: tmp
common:
    tags: introduction
```
